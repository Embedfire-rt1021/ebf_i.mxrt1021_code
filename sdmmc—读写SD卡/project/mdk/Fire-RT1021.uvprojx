# Keil uVision project Fire-RT1021.uvprojx, settings and files
target ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.10.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire-RT1021
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG,CPU_MIMXRT1021DAG5A,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\libraries;..\..\user;..\..\user\bsp;..\..\user\bsp\sdmmc\inc;..\..\user\bsp\sdmmc\port
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\MIMXRT1021xxxxx_ram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1021.c system_MIMXRT1021.h
  group startup
    ./: startup_MIMXRT1021.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_lpi2c.c fsl_usdhc.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group user
    ../../user/: main.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/bsp/sdmmc/src/: bsp_sd.c
    ../../user/bsp/delay/: core_delay.c
  group xip
    ../../user/xip/: fire_imxrt1021_sdram_ini_dcd.c fire_imxrt1021_spiflash_config.c fsl_flexspi_nor_boot.c
  group doc
    ../../doc/: 必读说明.txt
  group sdmmc
    ../../user/bsp/sdmmc/port/usdhc/polling/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../user/bsp/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
target nor_flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.10.0.0
  cpu: as above
  output: Fire-RT1021 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1021DAG5A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,SEMC_SDRAM_USED
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
