# Keil uVision project YH-RT1021.uvprojx, settings and files
target ram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.10.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1021
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MIMXRT1021DAG5A, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\libraries;..\..\user;..\..\user\bsp;..\..\user\lwip;..\..\user\lwip\port;..\..\user\lwip\src;..\..\user\lwip\src\include;..\..\user\lwip\src\include\lwip\apps;..\..\user\lwip\contrib\apps;..\..\user\bsp\lan8720a
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\MIMXRT1021xxxxx_ram.scf
  link misc: --remove
  group CMSIS
    ../../libraries/: system_MIMXRT1021.c system_MIMXRT1021.h
  group startup
    ./: startup_MIMXRT1021.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_enet.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
    ../../user/bsp/lan8720a/: fsl_phy.c
  group user
    ../../user/: main.c
  group xip
    ../../user/xip/: fire_imxrt1021_sdram_ini_dcd.c fire_imxrt1021_spiflash_config.c fsl_flexspi_nor_boot.c
  group lwip
    ../../user/lwip/src/apps/lwiperf/: lwiperf.c
    ../../user/lwip/src/include/lwip/apps/: lwiperf.h
    ../../user/lwip/port/: ethernetif.c ethernetif.h sys_arch.c
    ../../user/lwip/port/arch/: cc.h perf.h sys_arch.h
    ../../user/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../user/lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../user/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../user/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../user/lwip/src/netif/: ethernet.c lowpan6.c slipif.c
    ../../user/lwip/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group doc
    ../../doc/: 必读说明.txt
target nor_flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.10.0.0
  cpu: as above
  output: YH-RT1021 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1021DAG5A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\MIMXRT1021xxxxx_flexspi_nor.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
